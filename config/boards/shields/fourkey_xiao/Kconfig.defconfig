## config/boards/shields/fourkey_xiao/Kconfig.defconfig
```kconfig
if SHIELD_FOURKEY_XIAO

config ZMK_KEYBOARD_NAME
    default "FourKey XIAO"

endif
```
